XI1@1 NET1#1 AVSS nch_18_mac
XI1@2 NET1#6 AVSS nch_18_mac

R1 NET1#1 NET1#2 100
R2 NET1#2 NET1#3 100
R3 NET1#3 NET1#4 100
R4 NET1#4 NET1#5 100
R5 NET1#5 NET1#6 100
R6 NET1#6 NET1#7 100
R7 NET1#7 NET1#8 100
R8 NET1#8 NET1#9 100
