XI1@1 NET1#1 AVSS nch_18_mac
XI1@2 NET1#9 AVSS nch_18_mac

R1 NET1#1 NET1#2 1
R2 NET1#2 NET1#3 1
R3 NET1#3 NET1#4 1
R4 NET1#4 NET1#5 1
R5 NET1#5 NET1#6 1
R6 NET1#6 NET1#7 1
R7 NET1#7 NET1#8 1
R8 NET1#8 NET1#9 1

R9 NET1#2 NET1#10 1
R10 NET1#10 NET1#11 1
R11 NET1#11 NET1#5 1

R12 NET1#7 NET1#12 1
R13 NET1#12 NET1#13 1
R14 NET1#13 NET1#8 1
