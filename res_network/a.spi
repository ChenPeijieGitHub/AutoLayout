XI1@1 NET1#1 AVSS nch_18_mac
XI1@2 NET1#6 AVSS nch_18_mac

R1 NET1#1 NET1#2 200
R2 NET1#2 NET1#3 200
R3 NET1#3 NET1#4 200
R4 NET1#4 NET1#5 200
R5 NET1#5 NET1#6 200
R6 NET1#6 NET1#7 200
R7 NET1#7 NET1#8 200
R8 NET1#8 NET1#9 200
