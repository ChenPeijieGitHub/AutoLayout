R1 NET1#123 NET1#345 200
R2 NET1#123 NET1#346 200
R3 NET1#346 NET1#347 200
R4 NET1#346 NET1#347 200
R5 NET1#347 NET1#125 200
R6 NET1#125 NET1#126 200
R7 NET1#126 NET1#127 200
R8 NET1#347 NET1#127 200
